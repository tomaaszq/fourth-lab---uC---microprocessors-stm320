# Keil uVision project Szkielet_Projektu_LPC1114.uvproj, settings and files
target Szkielet_Projektu_LPC1114 (ARM-ADS)
  device: LPC1114/302 NXP
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Szkielet_Projektu_LPC1114
  c flags: Optim=1
  c include: .\Include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Device
    ./Device/: startup_LPC11xx.s system_LPC11xx.c
  group Source
    ./Source/: Szkielet_main.c
  group Library
    ./Library/: gpio.c
  group Interrupt
    ./Interrupt/: IRQ_SysTick.c
  group Abstract
    ./: Abstract.txt
  group Include
    ./Include/: gpio.h user_LPC1114.h
